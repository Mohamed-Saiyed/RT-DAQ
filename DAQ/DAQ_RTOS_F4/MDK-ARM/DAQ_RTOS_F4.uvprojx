# Keil uVision project DAQ_RTOS_F4.uvprojx, settings and files
target DAQ_RTOS_F4 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: DAQ_RTOS_F4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F446xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Source/include;../Source/portable/MemMang;../Source/portable/GCC/ARM_CM3;../Config;../Middlewares/Third_Party/FatFs/src;../Adafruit_BNO055;../DAQ_Tasks;../Encoder;../CAN;../FATFS/Target;../FATFS/App;..\Inductive Proximity Sensor;..\SUS Travel;../DataLogging
  library: MicroLIB
  memory RVCT4: ROM 0x8001000 size 0x7f000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: DAQ_RTOS_F4\DAQ_RTOS_F4.sct
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group FreeRtos
    ../Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Source/portable/GCC/ARM_CM3/: port.c
    ../Source/portable/MemMang/: heap_4.c
  group SUS Travell
    ../SUS Travel/: SUS_Travel.c
  group Adafruit_BNO055
    ../Adafruit_BNO055/: Adafruit_BNO055.c
  group DAQ_Tasks
    ../DAQ_Tasks/: DAQ_Tasks.c
  group Encoder
    ../Encoder/: Encoder.c
  group Inductive Proximity Sensor
    ../Inductive Proximity Sensor/: IndProximity.c
  group DAQ_CAN
    ../CAN/: DAQ_CAN.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group DataLogging
    ../DataLogging/: DataLogging.c
software components: CMSIS:CORE 5.4.0
